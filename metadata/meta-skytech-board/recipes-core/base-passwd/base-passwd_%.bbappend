ROOT_HOME = "/root"
