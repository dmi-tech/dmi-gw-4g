# Copyright (C) 2021 Fabien Parent <fparent@baylibre.com>
# Released under the MIT license (see COPYING.MIT for the terms)

require mdp-prebuilt.inc
require mdpd.inc

LIC_FILES_CHKSUM = "file://../LICENSE;md5=c25f59288708e3fd9961c9e6142aafee"
S = "${WORKDIR}/git/mdpd"
B = "${WORKDIR}/git/mdpd/${SOC_FAMILY}"
