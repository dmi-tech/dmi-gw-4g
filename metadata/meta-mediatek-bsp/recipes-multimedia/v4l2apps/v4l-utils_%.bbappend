FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += " \
	file://0001-Do-not-show-payload-info-if-show_payload-flag-off.patch \
"
