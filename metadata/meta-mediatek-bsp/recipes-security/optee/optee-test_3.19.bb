# Copyright (C) 2021 Fabien Parent <fparent@baylibre.com>
# Released under the MIT license (see COPYING.MIT for the terms)

require recipes-security/optee/optee-test.inc

SRCREV = "ab9863cc187724e54c032b738c28bd6e9460a4db"
COMPATIBLE_MACHINE = "mt*"
