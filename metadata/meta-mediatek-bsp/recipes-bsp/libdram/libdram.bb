require libdram.inc

DEPENDS:mt8365 = "libbase-prebuilt"
DEPENDS:mt8195 = "libbase-prebuilt"
