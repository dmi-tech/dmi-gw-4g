require recipes-bsp/mtk-secure-boot-tools/mtk-secure-boot-tools.inc

inherit setuptools3

BBCLASSEXTEND = "native"
