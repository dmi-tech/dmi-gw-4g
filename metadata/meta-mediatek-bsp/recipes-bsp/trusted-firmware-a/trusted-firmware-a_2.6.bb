require trusted-firmware-a-mtk_2.6.inc
