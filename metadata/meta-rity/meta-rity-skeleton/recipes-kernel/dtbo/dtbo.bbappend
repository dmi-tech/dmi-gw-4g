# WARNING: please update the rity docs if you modify this file

FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI:i500-skeleton += " \
	file://skeleton.dts \
"
