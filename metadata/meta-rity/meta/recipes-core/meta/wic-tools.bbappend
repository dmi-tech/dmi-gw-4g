
DEPENDS:append = " \
    python3-pysimg-native \
"
