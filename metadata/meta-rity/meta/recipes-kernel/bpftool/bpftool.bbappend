
# Allow aarch64 to build bpftool
COMPATIBLE_HOST = "(x86_64|aarch64).*-linux"