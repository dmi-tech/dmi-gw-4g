SRCREV = "405e5307d823f02fcc683e87686eb22d0887ef91"

SRC_URI:remove = " \
	file://0001-Add-stdout-mode-to-allow-streaming-over-the-network-.patch \
"
