FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += " \
           file://0001-stressapptest-Initialize-linesize.patch \
"


